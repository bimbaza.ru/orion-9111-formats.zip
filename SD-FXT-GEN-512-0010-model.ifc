Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: SD-FXT-GEN-512-0010-model.ifc
Time: 2026-09-03T23:23:28+00:00
Author: OOO PKF ORION, zavod-orion.ru
Organization: OOO PKF ORION, zavod-orion.ru
Written by: AutoCAD 2024
Made in: AutoCAD 2024
Authorization: OOO PKF ORION, zavod-orion.ru

# IfcBuildingElementProxy, SD-FXT-GEN-512-0010 Оборудование МГН «Инклюзивный глайдер»
In: Площадка
Pset_ManufacturerTypeInformation - Manufacturer: ООО «ПКФ «ОРИОН» · zavod-orion.ru · sales@zavod-orion.ru · 8 (351) 214-80-80; ModelLabel: SD-FXT-GEN-512-0010; ModelReference: Оборудование МГН «Инклюзивный глайдер»; ProductionYear: 2026
